# Keil uVision project 6_15 PWM定时器驱动电机.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 6_15 PWM定时器驱动电机 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c TIMER_0.h LCD.h key.c key.h
    ./6_15 PWM驱动/: TIMER_0.c
    ./6_8 动态数码管显示/: LCD.c
