# Keil uVision project 6_13 IIC通信.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 6_13 IIC通信
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c IIC.c IIC.h AT24C02.c AT24C02.h
